# Keil uVision project project.uvprojx, settings and files
target rtthread (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC, NIMBLE_CFG_CONTROLLER=1, NRF52832_XXAA
  c misc: --reduce_paths --gnu
  c include: applications;.;drivers;nordic;nordic\cmsis\include;nordic\nrfx;nordic\nrfx\drivers;nordic\nrfx\drivers\include;nordic\nrfx\drivers\src\prs;nordic\nrfx\hal;nordic\nrfx\mdk;nordic\nrfx\soc;nordic\nrfx\templates;packages\NimBLE-latest;packages\NimBLE-latest\nimble\include;packages\NimBLE-latest\nimble\host\include;packages\NimBLE-latest\nimble\host\src;packages\NimBLE-latest\nimble\host\services\ans\include;packages\NimBLE-latest\nimble\host\services\bas\include;packages\NimBLE-latest\nimble\host\services\bleuart\include;packages\NimBLE-latest\nimble\host\services\gap\include;packages\NimBLE-latest\nimble\host\services\gatt\include;packages\NimBLE-latest\nimble\host\services\ias\include;packages\NimBLE-latest\nimble\host\services\lls\include;packages\NimBLE-latest\nimble\host\services\tps\include;packages\NimBLE-latest\nimble\host\store\ram\include;packages\NimBLE-latest\nimble\host\util\include;packages\NimBLE-latest\porting\nimble\include;packages\NimBLE-latest\porting\npl\rtthread\include;packages\NimBLE-latest\ext\tinycrypt\include;packages\NimBLE-latest\nimble\transport\ram\include;packages\NimBLE-latest\nimble\controller\include;packages\NimBLE-latest\nimble\drivers\nrf52\include;packages\NimBLE-latest\apps\blehr\src;..\..\..\rt_code\rt-thread\include;..\..\..\rt_code\rt-thread\libcpu\arm\cortex-m4;..\..\..\rt_code\rt-thread\libcpu\arm\common;..\..\..\rt_code\rt-thread\components\dfs\include;..\..\..\rt_code\rt-thread\components\dfs\filesystems\devfs;..\..\..\rt_code\rt-thread\components\drivers\include;..\..\..\rt_code\rt-thread\components\drivers\include;..\..\..\rt_code\rt-thread\components\drivers\include;..\..\..\rt_code\rt-thread\components\finsh;..\..\..\rt_code\rt-thread\components\libc\compilers\armlibc;..\..\..\rt_code\rt-thread\components\libc\compilers\common
  asm define: BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c
  group drivers
    drivers/: board.c drv_uart.c
  group nordic
    nordic/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
    nordic/nrfx/drivers/src/prs/: nrfx_prs.c
    nordic/nrfx/drivers/src/: nrfx_adc.c nrfx_clock.c nrfx_gpiote.c nrfx_nfct.c nrfx_power.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_systick.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c nrfx_wdt.c
    nordic/nrfx/templates/: nrfx_glue.c
  group nimble
    packages/NimBLE-latest/nimble/host/src/: ble_att.c ble_att_clt.c ble_att_cmd.c ble_att_svr.c ble_eddystone.c ble_gap.c ble_gattc.c ble_gatts.c ble_hs_adv.c ble_hs_atomic.c ble_hs.c ble_hs_cfg.c ble_hs_conn.c ble_hs_dbg.c ble_hs_flow.c ble_hs_hci.c ble_hs_hci_cmd.c ble_hs_hci_evt.c ble_hs_hci_util.c ble_hs_id.c ble_hs_log.c ble_hs_mbuf.c ble_hs_mqueue.c ble_hs_misc.c ble_hs_pvcy.c ble_hs_startup.c ble_hs_stop.c ble_ibeacon.c ble_l2cap.c ble_l2cap_coc.c ble_l2cap_sig.c ble_l2cap_sig_cmd.c ble_monitor.c ble_sm_alg.c ble_sm.c ble_sm_cmd.c ble_sm_lgcy.c ble_sm_sc.c ble_store.c ble_store_util.c ble_uuid.c
    packages/NimBLE-latest/nimble/host/services/ans/src/: ble_svc_ans.c
    packages/NimBLE-latest/nimble/host/services/bas/src/: ble_svc_bas.c
    packages/NimBLE-latest/nimble/host/services/gap/src/: ble_svc_gap.c
    packages/NimBLE-latest/nimble/host/services/gatt/src/: ble_svc_gatt.c
    packages/NimBLE-latest/nimble/host/services/ias/src/: ble_svc_ias.c
    packages/NimBLE-latest/nimble/host/services/lls/src/: ble_svc_lls.c
    packages/NimBLE-latest/nimble/host/services/tps/src/: ble_svc_tps.c
    packages/NimBLE-latest/nimble/host/store/ram/src/: ble_store_ram.c
    packages/NimBLE-latest/nimble/host/util/src/: addr.c
    packages/NimBLE-latest/nimble/src/: ble_util.c
    packages/NimBLE-latest/porting/nimble/src/: nimble_port.c endian.c mem.c os_mbuf.c os_mempool.c os_msys_init.c os_cputime.c os_cputime_pwr2.c hal_timer.c
    packages/NimBLE-latest/porting/npl/rtthread/src/: modlog.c nimble_port_rtthread.c npl_os_rtthread.c nrf5x_isr.c
    packages/NimBLE-latest/ext/tinycrypt/src/: aes_decrypt.c aes_encrypt.c cmac_mode.c ecc.c ecc_dh.c utils.c
    packages/NimBLE-latest/nimble/transport/ram/src/: ble_hci_ram.c
    packages/NimBLE-latest/nimble/controller/src/: ble_ll_sched.c ble_ll_xcvr.c ble_ll_whitelist.c ble_ll_ctrl.c ble_ll_hci.c ble_ll_supp_cmd.c ble_ll_adv.c ble_ll_conn.c ble_ll_resolv.c ble_ll_conn_hci.c ble_ll_rand.c ble_ll.c ble_ll_scan.c ble_ll_dtm.c ble_ll_hci_ev.c
    packages/NimBLE-latest/nimble/drivers/nrf52/src/: ble_hw.c ble_phy.c
    packages/NimBLE-latest/apps/blehr/src/: blehr.c gatt_svr.c
  group Kernel
    ../../../rt_code/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../../rt_code/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../rt_code/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../rt_code/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../rt_code/rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../rt_code/rt-thread/components/drivers/misc/: pin.c
    ../../../rt_code/rt-thread/components/drivers/serial/: serial.c
    ../../../rt_code/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../rt_code/rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../../rt_code/rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../rt_code/rt-thread/components/libc/compilers/common/: gmtime_r.c
